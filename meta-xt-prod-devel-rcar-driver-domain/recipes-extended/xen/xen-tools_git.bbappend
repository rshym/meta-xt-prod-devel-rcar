PACKAGECONFIG:append:r8a779f0 = " \
    xsm \
"

FILES:${PN}-flask:r8a779f0 = " \
    /boot/xenpolicy-${XEN_REL}* \
"
